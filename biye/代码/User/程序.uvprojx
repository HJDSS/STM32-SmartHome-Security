# Keil uVision project 程序.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 程序 +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F103RC,STM32F10X_HD,USE_STDPERIPH_DRIVER,EN_FATFS_SD,EN_ONENET
  c include: ..\CMSIS;..\System\delay;..\System\sys;..\System\usart;..\System\bare_task_sched;..\System\osal_evt;..\User;..\Libraries\inc;..\Driver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CMSIS
    ../CMSIS/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../Libraries/src/: misc.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_spi.c
  group DRIVER
    ../Driver/: gpio.c timer.c stmflash.c as608.c key4_4.c usart3.c dht11.c dht11.h hc_sr501.c hc_sr501.h spi.c sd_spi.c sccb.c ov7670_fifo.c ov7670cfg_qvga_rgb565.c mq2.h mq2.c ov7670.h spi.h sd_spi.h usart2.c
  group USER
    ../Middlewares/FatFs/: ff.c diskio.c ffsystem.c
    ./: linkage.c linkage.h aes128.c aes128.h secure_store.c secure_store.h flash_store.h flash_store.c esp8266_tls.c esp8266_tls.h esp8266_onenet_mqtt.c esp8266_onenet_mqtt.h oled.h oled_remote.c oled_view.h oled_view.c app_types.h keyboard_sm.h keyboard_sm.c lock_manager.h lock_manager.c capture_task.c capture_task.h Capture.h Capture.c syslog.c syslog.h sd_capacity.h sd_capacity.c main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../System/usart/: usart1.c soft_uart_tx.c
    ../SYSTEM/bare_task_sched/: bare_task_sched.c
    ../SYSTEM/osal_evt/: osal_evt.c
